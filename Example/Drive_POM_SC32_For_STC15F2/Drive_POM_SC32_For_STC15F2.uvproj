# Keil uVision project Drive_POM_SC32_For_STC15F2.uvproj, settings and files
target Target_1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Drive_POM_SC32_For_STC15F2 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c
